RDEPENDS:${PN}:remove:qcom-custom-bsp = " \
    wlan-conf \
    hostap-daemon \
    "
