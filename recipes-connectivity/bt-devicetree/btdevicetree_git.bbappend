FILESPATH =+ "${TOPDIR}/../layers/meta-rubikpi/recipes-connectivity/bt-devicetree:"
SRC_URI += "file://0001_Delete_redundant_dai-link_nodes.patch"
