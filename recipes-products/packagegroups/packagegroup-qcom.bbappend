RDEPENDS:${PN}:remove = "packagegroup-qcom-wifi"
