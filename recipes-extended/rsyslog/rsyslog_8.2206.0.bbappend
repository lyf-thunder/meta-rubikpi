FILESEXTRAPATHS:prepend := "${WORKSPACE}/layers/meta-rubikpi/recipes-extended/rsyslog/rsyslog:"
