FILES:${PN} += "/*.img"
