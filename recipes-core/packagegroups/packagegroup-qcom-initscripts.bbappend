RDEPENDS:${PN} += " \
	initscripts-rubikpi-boot \
	initscripts-rubikpi-rtc \
	initscripts-rubikpi-bt \
	initscripts-rubikpi-wifi \
"
