FILESEXTRAPATHS:prepend := "${THISDIR}:${THISDIR}/partition-confs:"

SRC_URI += "file://001-generic-ufs-partitions.conf-Add-splash-image.patch"
