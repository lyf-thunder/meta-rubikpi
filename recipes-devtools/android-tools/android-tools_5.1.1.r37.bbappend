FILESEXTRAPATHS:prepend := "${WORKSPACE}/layers/meta-rubikpi/recipes-devtools/android-tools/files:"
