RDEPENDS:${PN}:append:qcm6490:qcom-custom-bsp = " \
    kernel-module-displaydlkm \
    qcom-display-hal-linux \
    qcom-displaydevicetree \
    "

RDEPENDS:${PN}:append:qcm6490:qcom-custom-distro = " \
    qcom-display-extn-linux \
    qcom-display-color-linux \
    "
