RDEPENDS:${PN}:append:qcom-custom-bsp = ' \
    notify \
'

