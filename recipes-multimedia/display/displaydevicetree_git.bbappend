FILESPATH =+ "${TOPDIR}/../layers/meta-rubikpi/recipes-multimedia/display/display-devicetree:"
SRC_URI += "file://0001-delete-ssc.patch"
