
FILESPATH =+ "${TOPDIR}/../src/vendor/qcom/opensource:"

SRC_URI = "file://kernel-6.6/techpack/display;protocol=file;name=display"

S = "${WORKDIR}/kernel-6.6/techpack/display"