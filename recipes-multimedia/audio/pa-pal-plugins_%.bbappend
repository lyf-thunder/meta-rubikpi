FILESPATH =+ "${TOPDIR}/../layers/meta-rubikpi/recipes-multimedia/audio/pa-pal-plugins:"

SRC_URI += "\
    file://0001-change_pulseaudio_config_file.patch \
    file://0002-Modify-HDMI-output-device.patch \
"
