FILESPATH =+ "${TOPDIR}/../layers/meta-rubikpi/recipes-multimedia/audio/pal:"
SRC_URI += "\
    file://0002-modifying-configuration-files.patch \
    file://0003-Modify-the-backend-used-by-the-speaker-mic.patch \
    file://0004-Enable-hdmi-to-add-a-new-device.patch \
"
