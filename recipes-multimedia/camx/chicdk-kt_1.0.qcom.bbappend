SRC_URI  = "file://${TOPDIR}/../src/vendor/qcom/proprietary/chi-cdk-kt/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"

